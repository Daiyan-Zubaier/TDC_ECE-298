v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {fine_delay_line.sym} 570 0 0 0 {name=x1}
C {medium_delay_line.sym} 180 0 0 0 {name=x2}
C {code_shown.sym} 820 -200 0 0 {name=s1 only_toplevel=false value=blabla}
C {counter.sym} -290 -130 0 0 {name=x3}
