v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {fine_delay_line.sym} 570 0 0 0 {name=x1}
C {medium_delay_line.sym} 180 0 0 0 {name=x2}
