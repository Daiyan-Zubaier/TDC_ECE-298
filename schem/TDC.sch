v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {type=primitive
format="@name @pinlist VDD VSS therm_encoder"
template="name=X1"}
E {}
C {fine_delay_line.sym} 570 0 0 0 {name=x1}
C {medium_delay_line.sym} 180 0 0 0 {name=x2}
C {code_shown.sym} 820 -200 0 0 {name=s1 only_toplevel=false value=blabla}
C {counter.sym} -290 -130 0 0 {name=x3}
C {medium_encoder.sym} -160 140 0 0 {}
C {fine_encoder.sym} 620 210 0 0 {name=X4}
